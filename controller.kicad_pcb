# Repository Doc-Raptor/dragon_controller_v2

File README.md:

This is a controller-board for 3d printers based on the LPC1768 and has five tmc2209 onboard. It is made for the Marlin Firmware and RepRapFirmware. It has a Port to plug a Demos D1 Mini directly on it or a Raspberry Pi can be connected to with just jumpercables (no resistors needed).
IT IS NOT FULLY TESTED!!!
NO FURTHER DEVELOPMENT. RepRapFirmware discountinues support for the LPC1768

## KiCad design controller.kicad_pcb

Board: 2 copper layers, 100.1 x 97.0 mm, 172 parts (0 on the bottom side), 161 nets.

Parts:
C1, C18, C25, C29, C30, C31, C34, C35, C36, C37, C40, C41, C42, C43, C46, C47, C48, C49, C51, C52, C54, C55: 100nF; C_1206_3216Metric
C2: 4.7uF; C_1206_3216Metric
C3, C4: 1uF; C_0805_2012Metric
C5: 33pF; C_0603_1608Metric
C6, C7, C8, C9, C10, C11, C12, C13, C21, C23: 0.1uF; C_0805_2012Metric
C14, C17, C57, C58: 12pF; C_0603_1608Metric
C15, C16, C19, C59: 10uF; C_1206_3216Metric
C20, C22, C24, C26, C53: 100uF; CP_Elec_6.3x7.7
C27, C33, C39, C45, C56: 2.2uF; C_1206_3216Metric
C28, C32, C38, C44, C50: 22nF; C_0603_1608Metric
D1: B140-13-F; D_SMA
D2, D3, D8, D11: 1N5819; D_SOD-123
F1: Fuse_Power; Fuseholder_Blade_Mini_Keystone_3568
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: EXP3; PinHeader_1x07_P2.54mm_Vertical
J2: TH_E0; PinHeader_1x03_P2.54mm_Vertical
J3: Power_IN; PhoenixContact_GMSTBVA_2,5_2-G-7,62_1x02_P7.62mm_Vertical
J4: DIAG_X; PinHeader_1x02_P2.54mm_Vertical
J5: Hotend_E0; PhoenixContact_MCV_1,5_2-G-5.08_1x02_P5.08mm_Vertical
J6: TH_B; PinHeader_1x03_P2.54mm_Vertical
J7: SV1; PinHeader_1x03_P2.54mm_Vertical
J8: Fan_Cooler; PinHeader_1x02_P2.54mm_Vertical
J9: DIAG_E0; PinHeader_1x01_P2.54mm_Vertical
J10: Power_Heat; PhoenixContact_GMSTBVA_2,5_2-G-7,62_1x02_P7.62mm_Vertical
J11: DIAG_Y; PinHeader_1x02_P2.54mm_Vertical
J12: DIAG_Z; PinHeader_1x02_P2.54mm_Vertical
J13: Z-; PinHeader_1x03_P2.54mm_Vertical
J15: Y-; PinHeader_1x03_P2.54mm_Vertical
J16: MAX_END; PinHeader_1x03_P2.54mm_Vertical
J17: X-; PinHeader_1x03_P2.54mm_Vertical
J18: DIAG_E1; PinHeader_1x01_P2.54mm_Vertical
J19: e1-Stepper; PinHeader_1x04_P2.54mm_Vertical
J20: e0-Stepper; PinHeader_1x04_P2.54mm_Vertical
J21: USB; PinHeader_1x04_P2.54mm_Vertical
J22: USB_5V; PinHeader_1x02_P2.54mm_Vertical
J23: Hotend_E1; PhoenixContact_MCV_1,5_2-G-5.08_1x02_P5.08mm_Vertical
J24: TH_E1; PinHeader_1x03_P2.54mm_Vertical
J25: EXP4; PinHeader_1x04_P2.54mm_Vertical
J26: PI; PinHeader_1x06_P2.54mm_Vertical
J29: EXP1; Multicomp_MC9A12-1034_2x05_P2.54mm_Vertical
J30: EXP2; Multicomp_MC9A12-1034_2x05_P2.54mm_Vertical
J31: Serial; PinHeader_1x04_P2.54mm_Vertical
J32: Micro_SD_Card_Det_Hirose_DM3AT; microSD_HC_Hirose_DM3AT-SF-PEJM5
J33: x-Stepper; PinHeader_1x04_P2.54mm_Vertical
J39: y-Stepper; PinHeader_1x04_P2.54mm_Vertical
J43: VCC; PinHeader_1x02_P2.54mm_Vertical
J44: z-Stepper; PinHeader_1x04_P2.54mm_Vertical
J45: 5V; PinHeader_1x02_P2.54mm_Vertical
J46: 3.3V; PinHeader_1x02_P2.54mm_Vertical
L1: 4.7uH; L_1812_4532Metric
L2: 22uH; L_0805_2012Metric
Q1, Q3, Q4: SE30150; TO-263-3_TabPin2
Q2: PMV40UN2; SOT-23
Q5: IRLML2244; SOT-23
R1: 124K; R_1206_3216Metric
R2: 1K; R_1206_3216Metric
R3, R7, R28, R29, R30, R31, R38: 10K; R_1206_3216Metric
R4: 23K7; R_1206_3216Metric
R5: 100K; R_1206_3216Metric
R6, R14, R19, R24, R27: 20K; R_1206_3216Metric
R8, R9, R10, R13, R15, R16, R20, R23, R25, R26: 0R11; R_1206_3216Metric
R11, R17, R35, R39, R40, R41, R42, R51: 100; R_1206_3216Metric
R12, R18, R21, R22, R36, R37: 4K7; R_1206_3216Metric
R32: 1K5; R_1206_3216Metric
R33, R34: 33K; R_1206_3216Metric
R43, R44, R45: 47; R_1206_3216Metric
R46: 470; R_1206_3216Metric
R48, R49, R50: 2K2; R_1206_3216Metric
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: MP2451; SOT-23-6
U2: LPC1768FBD100; LQFP-100_14x14mm_P0.5mm
U3: RT9013-33GB; SOT-23-5
U4, U5, U6, U7, U8: TMC2209-LA; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm_ThermalVias
U9: WeMos_D1_mini; WEMOS_D1_mini_light
Y1: 12Mhz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
+3V3: C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C21.1, C23.1, C25.1, C35.1, C41.1, C47.1, C52.1, J13.3, J15.3, J17.3, J32.4, J32.9, J46.1, L2.2, Q5.3, R7.2, R21.1, R22.1, R28.2, R29.2, R30.1, R31.1, R37.1, U2.19, U2.28, U2.42, U2.54, U2.71, U2.84, U2.96, U3.5, U4.15, U5.15, U6.15, U7.15, U8.15
+5V: C3.1, C5.1, C19.1, J7.2, J22.1, J29.1, J30.1, J31.1, J45.1, L1.1, R1.1, U3.1, U3.3, U9.9
BTN_EN1: J30.8, U2.26
BTN_EN2: J30.6, U2.27
BTN_SW: J29.9, R49.2, U2.24
Beeper: J29.10, U2.21, U9.13
DIR_E0: U2.49, U7.19
DIR_E1: U2.89, U8.19
DIR_X: U2.67, U4.19
DIR_Y: U2.58, U5.19
DIR_Z: U2.52, U6.19
EN_E0: U2.51, U7.2
EN_E1: U2.87, U8.2
EN_X: U2.74, U4.2
EN_Y: U2.65, U5.2
EN_Z: U2.57, U6.2
FET1: R17.1, R18.1, U2.68
FET2: R2.1, R3.1, U2.70
FET3: R11.1, R12.1, U2.66
FET4: R35.1, R36.1, U2.69
GND: C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.1, C30.2, C31.2, C33.1, C35.2, C36.2, C37.2, C39.1, C41.2, C42.2, C43.2, C45.1, C47.2, C48.2, C49.2, C52.2, C53.2, C54.2, C55.2, C56.1, C57.1, C58.1, C59.2, D1.2, J2.1, J2.2, J3.1, J6.1, J6.2, J7.1, J13.2, J15.2, J17.2, J21.4, J24.1, J24.2, J26.6, J29.2, J30.2, J31.2, J32.6, J32.11, J43.2, J45.2, J46.2, Q1.3, Q2.2, Q3.3, Q4.3, R3.2, R4.2, R6.1, R8.1, R9.1, R10.1, R12.2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
IO1: J25.1, R38.2, U2.53
IO2: J25.4, U2.46
IO3: J25.3, U2.47
IO4: J25.2, U2.48
IO5: J1.1, U2.80
IO6: J1.2, U2.81
IO7: J1.3, U2.82
IO8: J1.4, U2.85
IO9: J1.5, U2.86
IO10: J1.6, U2.95
IO11: J1.7, U2.6
LCD4: J29.6, U2.34
LCD5: J29.5, U2.35
LCD6: J29.4, U2.36
LCD7: J29.3, U2.37
LCDE: J29.8, U2.32
LCDRS: J29.7, U2.33
MISO: J30.10, R39.1, R45.2, U2.61
MOSI: J30.5, R44.2, R51.1, U2.60
unnamed: C1.1, D1.1, L1.2, U1.6
unnamed: C1.2, U1.1
unnamed: C5.2, R1.2, R4.1, U1.3
unnamed: C12.1, L2.1, U2.10, U2.12
unnamed: C14.2, U2.22, Y1.2
unnamed: C17.2, U2.23, Y1.1
unnamed: C27.2, U4.8
unnamed: C28.1, U4.5
unnamed: C28.2, U4.4
unnamed: C29.2, U4.6
unnamed: C32.1, U5.5
unnamed: C32.2, U5.4
unnamed: C33.2, U5.8
unnamed: C34.2, U5.6
unnamed: C38.1, U6.5
unnamed: C38.2, U6.4
unnamed: C39.2, U6.8
unnamed: C40.2, U6.6
unnamed: C44.1, U7.5
unnamed: C44.2, U7.4
unnamed: C45.2, U7.8
unnamed: C46.2, U7.6
unnamed: C50.1, U8.5
unnamed: C50.2, U8.4
unnamed: C51.2, U8.6
unnamed: C56.2, U8.8
unnamed: C57.2, J21.3, R34.1
unnamed: C58.2, J21.2, R32.1, R33.2
unnamed: D2.2, J8.2, Q2.3
unnamed: D3.2, J23.2, Q4.2
unnamed: D8.2, J5.2, Q3.2
unnamed: D11.2, J10.2, Q1.2
unnamed: F1.1, J3.2
unnamed: J4.2, U4.11
unnamed: J9.1, U7.11
unnamed: J11.2, U5.11
unnamed: J12.2, U6.11
unnamed: J18.1, U8.11
unnamed: J19.1, U8.21
unnamed: J19.2, U8.24
unnamed: J19.3, U8.26
unnamed: J19.4, U8.1
unnamed: J20.1, U7.21
unnamed: J20.2, U7.24
unnamed: J20.3, U7.26
unnamed: J20.4, U7.1
unnamed: J21.1, J22.2
unnamed: J26.1, R51.2
unnamed: J26.2, R39.2
unnamed: J26.3, R40.2
unnamed: J26.4, R41.2
unnamed: J26.5, R42.2
unnamed: J33.1, U4.21
unnamed: J33.2, U4.24
unnamed: J33.3, U4.26
unnamed: J33.4, U4.1
unnamed: J39.1, U5.21
unnamed: J39.2, U5.24
unnamed: J39.3, U5.26
unnamed: J39.4, U5.1
unnamed: J44.1, U6.21
unnamed: J44.2, U6.24
unnamed: J44.3, U6.26
unnamed: J44.4, U6.1
unnamed: Q1.1, R17.2
unnamed: Q2.1, R2.2
unnamed: Q3.1, R11.2
unnamed: Q4.1, R35.2
unnamed: Q5.2, R32.2
unnamed: R5.1, U1.4
unnamed: R8.2, U4.23
unnamed: R9.2, U4.27
unnamed: R10.2, U5.23
unnamed: R13.2, U5.27
unnamed: R15.2, U6.23
unnamed: R16.2, U6.27
unnamed: R20.2, U7.23
unnamed: R23.2, U7.27
unnamed: R25.2, U8.23
unnamed: R26.2, U8.27
unnamed: R43.1, U9.4
unnamed: R44.1, U9.6
unnamed: R45.1, U9.5
unnamed: R46.1, U9.1
unnamed: R48.1, U9.7
unnamed: R49.1, U9.12
RESET: C13.1, J30.3, R7.1, SW1.2, U2.17
SCK: J30.9, R40.1, R43.2, U2.62
SD_CS: J32.2, R28.1, U2.79
SD_CS_LCD: J30.7, R41.1, R48.2, U2.63
SD_DETECT: J30.4, R42.1, R46.2, R50.2, U2.20
SD_D_ONBOARD: J32.10, U2.25
SD_MISO: J32.7, R30.2, U2.77
SD_MOSI: J32.3, R29.1, U2.76
SD_SCK: J32.5, R31.2, U2.78
STEP_E0: U2.50, U7.16
STEP_E1: U2.88, U8.16
STEP_X: U2.73, U4.16
STEP_Y: U2.59, U5.16
STEP_Z: U2.56, U6.16
SV1: J7.3, U2.75
S_E0: R24.2, U2.93, U7.14
S_E1: R27.2, U2.94, U8.14
S_X: R6.2, U2.90, U4.14
S_Y: R14.2, U2.91, U5.14
S_Z: R19.2, U2.92, U6.14
T1: C15.1, J2.3, R21.2, U2.8
T2: C16.1, J6.3, R22.2, U2.9
T3: C59.1, J24.3, R37.2, U2.7
URX0: J31.3, U2.99
USB_CONN: Q5.1, U2.64
USB_D+: R33.1, U2.29
USB_D-: R34.2, U2.30
UTX0: J31.4, U2.98
VDD: C2.1, C18.1, C20.1, C22.1, C24.1, C26.1, C29.1, C30.1, C31.1, C34.1, C36.1, C37.1, C40.1, C42.1, C43.1, C46.1, C48.1, C49.1, C51.1, C53.1, C54.1, C55.1, D2.1, D3.1, D8.1, D11.1, F1.2, J5.1, J8.1, J10.1, J23.1, J43.1, R5.2, U1.5, U4.22, U4.28, U5.22, U5.28, U6.22, U6.28, U7.22, U7.28, U8.22, U8.28
X-MAX: J16.1, U2.38
X-MIN: J4.1, J17.1, U2.43
Y-MAX: J16.2, U2.39
Y-MIN: J11.1, J15.1, U2.44
Z-MAX: J16.3, U2.40
Z-MIN: J12.1, J13.1, U2.45

## Commit log

2020-08-30 Ready for test
2020-08-30 new files for manufacturing
2021-02-15 New PCB layout and some mods
2021-02-16 Fix some mistakes
2021-02-19 Fix some stuff
